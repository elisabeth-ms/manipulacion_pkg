Commit message: Fix schunk collision detection.

File: urdf/schunk.urdf (robot description, URDF)
Before this commit: robot caja_simple_robot, 2 links, 1 joints
Links:
- link link_caja: geometry collision box size=0.26 0.2 0.24; visual box size=0.26 0.2 0.24
