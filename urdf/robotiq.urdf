Commit message: Fix collision detection model robotiq.

File: urdf/robotiq.urdf (robot description, URDF)
Before this commit: robot caja_simple_robot, 2 links, 1 joints
Links:
- link link_caja: geometry collision box size=0.26 0.24 0.14; visual box size=0.26 0.24 0.14
